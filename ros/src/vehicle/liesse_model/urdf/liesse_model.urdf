Commit message: 2020_01_17

File: ros/src/vehicle/liesse_model/urdf/liesse_model.urdf (robot description, URDF)
Before this commit: robot liesse_model, 1 links, 0 joints
Links:
- link base_link: mass 26585.0676830834 -> 31203
